# Keil uVision project ReactiveJammer.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: UWBProject +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Drivers\BSP\STM32F7xx_Nucleo_144;.\RTE\Device\STM32F746ZGTx\STCubeGenerated\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;.\RTE\Device\STM32F746ZGTx\STCubeGenerated\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\RTE\Device\STM32F746ZGTx\STCubeGenerated\Inc;.\Drivers\BSP\Decawave\application;.\Drivers\BSP\Decawave\compiler;.\Drivers\BSP\Decawave\decadriver;.\Drivers\BSP\Decawave\platform;.\Drivers\BSP\Decawave\usb;..\UWB_PROJECT_TX;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.0.0\CMSIS\RTOS\RTX\SRC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Drivers\BSP\STM32F7xx_Nucleo_144
    ./Drivers/BSP/STM32F7xx_Nucleo_144/: stm32f7xx_nucleo_144.c stm32f7xx_nucleo_144.h
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F746ZGTx/STCubeGenerated/Src/: main.c stm32f7xx_it.c
    ./RTE/Device/STM32F746ZGTx/STCubeGenerated/Inc/: stm32f7xx_it.h
  group Middlewares\USB_Device_Library
    ./RTE/Device/STM32F746ZGTx/STCubeGenerated/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ./RTE/Device/STM32F746ZGTx/STCubeGenerated/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Decawave\application
    ./Drivers/BSP/Decawave/application/: dw_main.c instance.c instance_calib.c instance_common.c instance.h lib.h
  group Decawave\compiler
    ./Drivers/BSP/Decawave/compiler/: compiler.h
  group Decawave\decadriver
    ./Drivers/BSP/Decawave/decadriver/: deca_device.c deca_device_api.h deca_param_types.h deca_params_init.c deca_regs.h deca_types.h deca_version.h
  group Decawave\usb
    ./Drivers/BSP/Decawave/usb/: deca_usb.c deca_usb.h
  group Decawave\platform
    ./Drivers/BSP/Decawave/platform/: deca_mutex.c deca_range_tables.c deca_sleep.c deca_spi.c deca_spi.h port.c port.h sleep.h
  group USB
    ./RTE/Device/STM32F746ZGTx/STCubeGenerated/Src/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group User\Threading
    ./: uartThread.c commands.h commands.c JMThread.c common.h
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS:Keil RTX 4.81.0, Device:STM32Cube HAL:Common 1.2.0, Device:STM32Cube HAL:Cortex 1.2.0, Device:STM32Cube HAL:DMA 1.2.0, Device:STM32Cube HAL:ETH 1.2.0, Device:STM32Cube HAL:GPIO 1.2.0, Device:STM32Cube HAL:HCD 1.2.0, Device:STM32Cube HAL:PCD 1.2.0, Device:STM32Cube HAL:PWR 1.2.0, Device:STM32Cube HAL:RCC 1.2.0, Device:STM32Cube HAL:SPI 1.2.0, Device:STM32Cube HAL:UART 1.2.0, Device:Startup 1.2.0
