# Keil uVision project STCubeGenerated.uvprojx, settings and files
target STCubeGenerated (ARM-ADS)
  device: STM32F746ZGTx STMicroelectronics
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STCubeGenerated
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ../Inc;               ../Drivers/STM32F7xx_HAL_Driver/Inc;               ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;               ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;               ../Drivers/CMSIS/Include;         ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;         ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_flash.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma.c stm32f7xx_hal.c stm32f7xx_hal_tim.c stm32f7xx_hal_uart.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_spi.c stm32f7xx_ll_usb.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f7xx.c
  group Application/User
    ../Src/: stm32f7xx_hal_msp.c main.c stm32f7xx_it.c usbd_desc.c usbd_conf.c usb_device.c usbd_cdc_if.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
